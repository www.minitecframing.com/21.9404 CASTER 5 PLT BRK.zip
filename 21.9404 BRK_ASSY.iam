# Autodesk Inventor assembly: 21.9404 BRK_ASSY
## iProperties
Created: 2010-10
Part Number: 21.9404 BRK_ASSY
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
